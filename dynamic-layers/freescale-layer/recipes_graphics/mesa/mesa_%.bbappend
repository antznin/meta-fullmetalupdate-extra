# PACKAGECONFIG_append_imx6qdlsabresd = " osmesa"
# DRIDRIVERS_append_imx6qdlsabresd = "swrast"
# PACKAGECONFIG_remove_imx6qdlsabresd = "gallium"
